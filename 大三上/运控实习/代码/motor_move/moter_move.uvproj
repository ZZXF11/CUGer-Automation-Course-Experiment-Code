# Keil uVision project moter_move.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: moter_move +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\motor_move
  group Source Group 1
    ./: main.c move.c key.c lcd.c
